# Keil uVision project STM32F107MDKNET.uvprojx, settings and files
target STM32F107 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F107MDKNET
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: HTTP_Server_CGI.c HTTP_Server_Error.c main.c RS485.c UDP_Socket.c flash_rw.c
    Web/: web.c
  group Web Files
    ./Web/: ad.cgi ad.cgx buttons.cgi buttons.cgx home.png index.htm keil.gif language.cgi lcd.cgi leds.cgi llblue.jpg logo.gif network.cgi pabb.gif pg_footer.inc pg_header.inc system.cgi tcp.cgi xml_http.js
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS2:Keil RTX5 5.1.0, Network:CORE 7.5.0, Network:Interface:ETH 7.5.0, Network:Service:Web Server Compact 7.5.0, Network:Socket:TCP 7.5.0, Network:Socket:UDP 7.5.0, CMSIS Driver:Ethernet MAC 2.1, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, CMSIS Driver:USART 2.2, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
